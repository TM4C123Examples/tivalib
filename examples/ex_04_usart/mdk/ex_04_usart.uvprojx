# Keil uVision project ex_04_usart.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ex_01_gpio
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\tivalib\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ../source/: main.c
  group tivalib
    ../../../tivalib/source/: board_tm4c123gxl.c delay.c serial_stdio.c serial_tm4c.c uart_tm4c.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
